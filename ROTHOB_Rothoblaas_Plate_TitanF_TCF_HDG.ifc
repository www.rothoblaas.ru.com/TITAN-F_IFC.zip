Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , ,], Description [RB]
Time: 2025-08-08T10:50:27
Author: Augusto Meorali
Organization: ROTHO BLAAS SRL
Written by: EDMsix Version 602.28.129 Aug 2 2022
Made in: AutoCAD Architecture 2024 - Italiano (Italian) Build 8.6.52.0
Comment: STEP Physical File produced by: EDMsix Version 602.28.129 Aug 2 2022 * Module: EDMstepFileFactory v4.0.1/EDMstandAlone * Creation date: 20250808 10:50:27 * Host: NBK-MEORALI.rothoit.local * Database: C:\Users\augustom\AppData\Local\Temp\ACAIFCTMP/EDM34184\aec_ifc_db * Database version: 6007 * Database creation date: Fri Aug 8 08:01:50 2025 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri Aug 8 10:50:27 2025 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Aug 8 10:50:27 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 10522 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 01
LongName: ROTHOB_Rothoblaas_Plate_TitanF_TCF
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Pianta 1-50; ACA_DISPLAY_SET_ON_EXPORT: Modello 1-50

# IfcBuilding, ROTHOB_Rothoblaas_Plate_TitanF_TCF
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
