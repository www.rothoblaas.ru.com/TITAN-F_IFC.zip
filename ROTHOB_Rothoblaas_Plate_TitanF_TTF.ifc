Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 7face9af-6fa5-484f-b3ee-1050b37c047f, NumberOfSaves: 25], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_TitanF_TTF.ifc
Time: 2025-06-23T17:19:32
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_TitanF_TTF : 200x71x71mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_DX51D-Z275
Type - Generale - Author: ROTHO BLAAS SRL; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/titan-f; Revision: 001; UniClass2015Code: Pr_20_85_09_11; UniClass2015Title: Carbon steel brackets; UniClass2015Version: Products v1.38; Version: 002
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_DX51D-Z275
Type - Quote - Height_H: 71 mm; HoleQuantity_nhØ5: 30; HoleQuantity_nvØ5: 30; Length_B: 200 mm; Thickness_s: 3 mm; Width_P: 71 mm
Type - Dati identità - Descrizione: Angle bracket for shear forces; Nome del tipo: 200x71x71mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_09_11: Carbon steel brackets; CECode: ETA 11/0496; CETitle: Rotho Blaas TITAN Angle Brackets; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Angle bracket for shear forces; DurationUnit: Years; ExpectedLife: 50; Features: TITAN angle bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: Zinc plated; Grade: n/a; GTIN: 8054247470258; Manufacturer: info@rothoblaas.com; Material: DX51D+Z275 zinc plated carbon steel; MinWeight: 0.583kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: TTF200; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_TitanF_TTF; NominalHeight: 71 mm; NominalLength: 200 mm; NominalWidth: 71 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 200x71x71mm; SustainabilityPerformance: BVB Accepted / Sundahus A; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_85_09_11: Carbon steel brackets
Pset_QuantityTakeOff - Reference: 200x71x71mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.0000793847 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_TitanF_TTF; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_TitanF_TTF: 200x71x71mm; ID tipo: 289905; Tipo: 200x71x71mm
